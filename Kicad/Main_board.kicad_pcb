# Repository Jean-K3/Gate_O_matix

File README.md:

Gate sequencer by Plop

  Update 17 FEB 2021

  64 step sequencer, 8 parts
  Multiple play mode
  Eurorack format

  ________________________________________________________________________________________________
  ________________________________________________________________________________________________
  ________________________________________________________________________________________________

  TODO :

    SOFTWARE

      -Clock multiplier/divider per part
      -Detect clock internal/external (switching jack)
      -Reset -> interupt
      -Patern choice
      -Save/Load (SD card)

    HARDWARE

      -Use faster microcontroler (blue pills or teensy ?)
      -Add switching jack for clock
      -Add SD card
      -12v alimentation
      -"transistorisation" des entrées/sorties

    SCHEMATIC & PCB
    
      -Resistor value for LED & screen
      -Routing Main_Board
      -Drawing CPU_Board

  DONE :

    -Tempo
    -Screen driver
    -LED driver
    -Key matrix
    -Part choice
    -Number of step
    -Pages navigation
    -Step ON-OFF
    -Play mode
    -Fill/Clear
    -Copy/Past
    -Pause/Play/Stop
    -Gate size
    -Step jump
    -Reset
    -Internal clock

  ________________________________________________________________________________________________
  ________________________________________________________________________________________________
  ________________________________________________________________________________________________

  FUNCTIONS :

    Buttons =
        -Step on/off
        -Shift + step button = step jump
        -Fill
        -Fill + shift = Clear
        -Copy/Paste
        -Copy/Paste + shift = Save
        -Pause/Play
        -Pause/Play + shift = Stop

    Encoders =
        -Tempo
        -Tempo + push = clock divider
        -Gate length
        -Gate length + push = Number of step
        -Page navigation
        -Page navigation + push = Play mode

    Selector =
        -Part choice

    Play mode =
        -Forward
        -Backward
        -Ping Pong
        -Random
        -Brownien

  --------------------------------------------------------------------------

## KiCad design Kicad/Main_board.kicad_pcb

Parts:
D1, D2, D3, D4, D5, D6, D7, D8, D9, D10, D11, D12, D13, D14, D15, D16: LED_BLUE; LED_5.0mm
D17, D18, D19, D20, D21, D22, D23, D24, D25, D26, D27, D28, D29, D30, D31, D32: LED_GREEN; LED_5.0mm
D33, D34, D35, D36, D37, D38, D39, D40, D41, D42, D43, D44, D45, D46, D47, D48, D49, D50, D51, D52: 1N4148; D_DO-35_SOD27_P7.62mm_Horizontal
D53, D54, D55: LED; LED_5.0mm
J1: Data & Power; IDC-Header_2x05
J2: Data 2; IDC-Header_2x08
J3: Data 3; IDC-Header_2x08
R1, R2, R3, R4, R5, R6, R7, R8, R9, R10, R11, R12, R13, R14, R15, R16, R17, R18, R19, R20, R21, R22, R23, R24, R25, R26, R27, R28, R29, R30, R31, R32: R; Resistance
R33, R34, R35: ?; Resistance
R36, R37, R38, R39, R40, R41: 50k; Resistance
R42, R43, R44: 220; Resistance
SW1, SW2, SW3, SW4, SW5, SW6, SW7, SW8, SW9, SW10, SW11, SW12, SW13, SW14, SW15, SW16, SW17, SW18, SW19, SW20: SW_Push; SW_PUSH-12mm(deported)
SW21, SW22, SW23: Rotary_Encoder_Switch; RotaryEncoder
SW24: Rotary_switch_8S.1P_(voltage_divider); SolderWirePad_1x03_Drill1.5mm
U1, U2, U3, U4: 74HC595; DIP-16_Socket
U5: 7_segment_3_digit_2831AS; 7-Segment_2831AS

Connections:
1: D33.1 (K), D34.1 (K), D35.1 (K), D36.1 (K), D37.1 (K), J2.2
2: D38.1 (K), D39.1 (K), D40.1 (K), D41.1 (K), D42.1 (K), J2.3
3: D43.1 (K), D44.1 (K), D45.1 (K), D46.1 (K), D47.1 (K), J2.4
4: D48.1 (K), D49.1 (K), D50.1 (K), D51.1 (K), D52.1 (K), J2.5
+5V: J1.6, R36.2, R37.2, R38.2, R39.2, R40.2, R41.2, SW24.1, U1.10 (~SRCLR), U1.16 (VCC), U2.10 (~SRCLR), U2.16 (VCC), U3.10 (~SRCLR), U3.16 (VCC), U4.10 (~SRCLR), U4.16 (VCC)
A: J2.6, SW1.2, SW6.2, SW11.2, SW16.2
B: J2.7, SW2.2, SW7.2, SW12.2, SW17.2
C: J2.8, SW3.2, SW8.2, SW13.2, SW18.2
Clock_1: J2.10, U1.11 (SRCLK), U2.11 (SRCLK)
Clock_2: J2.13, U3.11 (SRCLK), U4.11 (SRCLK)
D: J2.16, SW4.2, SW9.2, SW14.2, SW19.2
Data_1: J2.9, U1.14 (SER)
Data_2: J2.12, U3.14 (SER)
E: J2.15, SW5.2, SW10.2, SW15.2, SW20.2
GND: D1.1 (K), D2.1 (K), D3.1 (K), D4.1 (K), D5.1 (K), D6.1 (K), D7.1 (K), D8.1 (K), D9.1 (K), D10.1 (K), D11.1 (K), D12.1 (K), D13.1 (K), D14.1 (K), D15.1 (K), D16.1 (K), D17.1 (K), D18.1 (K), D19.1 (K), D20.1 (K), D21.1 (K), D22.1 (K), D23.1 (K), D24.1 (K), D25.1 (K), D26.1 (K), D27.1 (K), D28.1 (K), D29.1 (K), D30.1 (K), D31.1 (K), D32.1 (K), D53.1 (K), D54.1 (K), D55.1 (K), J1.7, J1.8, SW21.C, SW21.S2, SW22.C, SW22.S2, SW23.C, SW23.S2, SW24.3, U1.8 (GND), U1.13 (~OE), U2.8 (GND), U2.13 (~OE), U3.8 (GND), U3.13 (~OE), U4.8 (GND), U4.13 (~OE)
Latch_1: J2.11, U1.12 (RCLK), U2.12 (RCLK)
Latch_2: J2.14, U3.12 (RCLK), U4.12 (RCLK)
unnamed: D1.2 (A), R1.1
unnamed: D2.2 (A), R2.1
unnamed: D3.2 (A), R3.1
unnamed: D4.2 (A), R4.1
unnamed: D5.2 (A), R5.1
unnamed: D6.2 (A), R6.1
unnamed: D7.2 (A), R7.1
unnamed: D8.2 (A), R8.1
unnamed: D9.2 (A), R9.1
unnamed: D10.2 (A), R10.1
unnamed: D11.2 (A), R11.1
unnamed: D12.2 (A), R12.1
unnamed: D13.2 (A), R13.1
unnamed: D14.2 (A), R14.1
unnamed: D15.2 (A), R15.1
unnamed: D16.2 (A), R16.1
unnamed: D17.2 (A), R17.1
unnamed: D18.2 (A), R18.1
unnamed: D19.2 (A), R19.1
unnamed: D20.2 (A), R20.1
unnamed: D21.2 (A), R21.1
unnamed: D22.2 (A), R22.1
unnamed: D23.2 (A), R23.1
unnamed: D24.2 (A), R24.1
unnamed: D25.2 (A), R25.1
unnamed: D26.2 (A), R26.1
unnamed: D27.2 (A), R27.1
unnamed: D28.2 (A), R28.1
unnamed: D29.2 (A), R29.1
unnamed: D30.2 (A), R30.1
unnamed: D31.2 (A), R31.1
unnamed: D32.2 (A), R32.1
unnamed: D33.2 (A), SW1.1
unnamed: D34.2 (A), SW2.1
unnamed: D35.2 (A), SW3.1
unnamed: D36.2 (A), SW4.1
unnamed: D37.2 (A), SW5.1
unnamed: D38.2 (A), SW6.1
unnamed: D39.2 (A), SW7.1
unnamed: D40.2 (A), SW8.1
unnamed: D41.2 (A), SW9.1
unnamed: D42.2 (A), SW10.1
unnamed: D43.2 (A), SW11.1
unnamed: D44.2 (A), SW12.1
unnamed: D45.2 (A), SW13.1
unnamed: D46.2 (A), SW14.1
unnamed: D47.2 (A), SW15.1
unnamed: D48.2 (A), SW16.1
unnamed: D49.2 (A), SW17.1
unnamed: D50.2 (A), SW18.1
unnamed: D51.2 (A), SW19.1
unnamed: D52.2 (A), SW20.1
unnamed: D53.2 (A), R42.2
unnamed: D54.2 (A), R43.2
unnamed: D55.2 (A), R44.2
unnamed: R1.2, U1.15 (QA)
unnamed: R2.2, U1.1 (QB)
unnamed: R3.2, U1.2 (QC)
unnamed: R4.2, U1.3 (QD)
unnamed: R5.2, U1.4 (QE)
unnamed: R6.2, U1.5 (QF)
unnamed: R7.2, U1.6 (QG)
unnamed: R8.2, U1.7 (QH)
unnamed: R9.2, U2.15 (QA)
unnamed: R10.2, U2.1 (QB)
unnamed: R11.2, U2.2 (QC)
unnamed: R12.2, U2.3 (QD)
unnamed: R13.2, U2.4 (QE)
unnamed: R14.2, U2.5 (QF)
unnamed: R15.2, U2.6 (QG)
unnamed: R16.2, U2.7 (QH)
unnamed: R17.2, U3.15 (QA)
unnamed: R18.2, U3.1 (QB)
unnamed: R19.2, U3.2 (QC)
unnamed: R20.2, U3.3 (QD)
unnamed: R21.2, U3.4 (QE)
unnamed: R22.2, U3.5 (QF)
unnamed: R23.2, U3.6 (QG)
unnamed: R24.2, U3.7 (QH)
unnamed: R25.2, U4.15 (QA)
unnamed: R26.2, U4.1 (QB)
unnamed: R27.2, U4.2 (QC)
unnamed: R28.2, U4.3 (QD)
unnamed: R29.2, U4.4 (QE)
unnamed: R30.2, U4.5 (QF)
unnamed: R31.2, U4.6 (QG)
unnamed: R32.2, U4.7 (QH)
unnamed: R33.2, U5.7 (CA1)
unnamed: R34.2, U5.10 (CA2)
unnamed: R35.2, U5.11 (CA3)
unnamed: U1.9 (QH'), U2.14 (SER)
unnamed: U3.9 (QH'), U4.14 (SER)
Screen_A: J1.1, U5.8 (A)
Screen_B: J1.2, U5.12 (B)
Screen_C: J1.3, U5.4 (C)
Screen_CA1: J3.12, R33.1
Screen_CA2: J3.11, R34.1
Screen_CA3: J3.10, R35.1
Screen_D: J1.4, U5.2 (D)
Screen_DP: J3.9, U5.3 (DP)
Screen_E: J1.5, U5.1 (E)
Screen_F: J1.10, U5.9 (F)
Screen_G: J1.9, U5.5 (G)
Selector_pin: J2.1, SW24.2
ecdr_clock_1: J3.1, R36.1, SW21.A
ecdr_clock_2: J3.5, R37.1, SW22.A
ecdr_clock_3: J3.16, R38.1, SW23.A
ecdr_data_1: J3.3, R39.1, SW21.B
ecdr_data_2: J3.7, R40.1, SW22.B
ecdr_data_3: J3.14, R41.1, SW23.B
ecdr_led_1: J3.4, R42.1
ecdr_led_2: J3.8, R43.1
ecdr_led_3: J3.13, R44.1
ecdr_sw_1: J3.2, SW21.S1
ecdr_sw_2: J3.6, SW22.S1
ecdr_sw_3: J3.15, SW23.S1

Notes on the sheet:
Tempo LED & Shift-registers
Step LED & Shift-register
Buttons matrix
Encoders & LED
Selector (Voltage divider)
Screen
Connectors

Board: 2 copper layers, 213.0 x 128.5 mm, 131 parts (0 on the bottom side), 133 nets.

## Commit log

2021-02-14 supprimé : Gate_O_Matix_v_0.1/Gate_O_Matix_v_0.1.ino supprimé : Gate_O_Matix_v_0.2.ino nouveau fichier : Master_seq/Master_seq.ino modifié : README.md nouveau fichier : Slave_seq.2/Slave_seq.2.ino no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
2021-02-14 nouveau fichier : Gate_omatik.sch
2021-02-16 supprimé : Gate_omatik.sch nouveau fichier : Kicad/CPU_board.pro nouveau fichier : Kicad/CPU_board.sch nouveau fichier : Kicad/Main_board.pro nouveau fichier : Kicad/Main_board.sch nouveau fichier : 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
2021-02-16 supprimé : Kicad/CPU_board-cache.lib modifié : Kicad/CPU_board.pro modifié : Kicad/CPU_board.sch supprimé : Kicad/CPU_board.sch-bak supprimé : Kicad/Main_board-cache.lib modifié : Kicad/Main_board.sc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
2021-02-16 nouveau fichier : My_library/00_Mes_empreintes.pretty/2X05_Power_conn.kicad_mod nouveau fichier : My_library/00_Mes_empreintes.pretty/2n3904.kicad_mod nouveau fichier : My_library/00_Mes_empreintes.p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
2021-02-16 nouveau fichier : Kicad/Main_board-cache.lib nouveau fichier : Kicad/Main_board.kicad_pcb nouveau fichier : Kicad/Main_board.kicad_pcb-bak nouveau fichier : Kicad/Main_board.net modifié : Kicad/Main_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
2021-02-16 supprimé : Main_board-cache.lib supprimé : Main_board.kicad_pcb-bak supprimé : Main_board.sch-bak supprimé : fp-info-cache supprimé : sym-lib-table
2021-02-16 modifié : CPU_board.sch modifié : Main_board.kicad_pcb modifié : Main_board.sch
2021-02-17 modifié : Kicad/Main_board-cache.lib modifié : Kicad/Main_board.kicad_pcb modifié : Kicad/Main_board.net modifié : Kicad/Main_board.sch nouveau fichier : Kicad/My_library/00_Mes_empreintes.pretty/7-S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
2021-02-19 modifié : Kicad/Main_board.kicad_pcb modifié : README.md
2021-02-19 modifié : Kicad/Main_board.kicad_pcb
